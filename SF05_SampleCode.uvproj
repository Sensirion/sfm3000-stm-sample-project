# Keil uVision project SF05_SampleCode.uvproj, settings and files
target STM32-Discovery (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SF05_SampleCode
  c flags: Optim=1
  c define: STM32F10X_MD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    C:/Keil/ARM/Startup/ST/STM32F10x/: startup_stm32f10x_md_vl.s
  group Source Files
    ./Source/: i2c_hal.c main.c sf05.c system.c
